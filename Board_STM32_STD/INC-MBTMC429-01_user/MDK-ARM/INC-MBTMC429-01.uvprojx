# Keil uVision project INC-MBTMC429-01.uvprojx, settings and files
target microcontroller (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: inc_mbtmc429_user_35 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib;..\STM32F10x_FWLib\inc;..\Inc;..\User;..\project
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Inc
    ../Inc/: bits.h main.h SysTick.h IO.h UART.h Timer.h SPI.h TMC429.h TMC262.h Globals.h Eeprom.h IIC_Soft.h 24CXX.h SysControl.h
  group Src
    ../Src/: SysTick.c UART.c Timer.c IO.c SPI.c TMC262.c TMC429.c Globals.c Eeprom.c IIC_Soft.c 24CXX.c SysControl.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Project
    ../project/: button.c button.h Lidopen.c Lidopen.h JABIL_LCR.c JABIL_LCR.h
  group Commands
    ../Inc/: Commands.h
    ../project/: Commands.c cmd_io.c cmd_eeprom.c cmd_motor.c cmd_BUTTONT_TEST.c cmd_LIDOPEN.c cmd_IAC_LCR.c cmd_JABIL_LCR.c
    ../commands/: cmd_tmc429.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_exti.c
    ../STM32F10x_FWLib/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../Doc/: PinSet.txt readme.txt
